<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f746bg_uart_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
